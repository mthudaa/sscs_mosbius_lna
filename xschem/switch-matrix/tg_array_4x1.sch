v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {lab_wire.sym} 600 -170 0 1 {name=p1 lab=VDD}
C {lab_wire.sym} 600 -150 0 1 {name=p2 lab=VSS}
C {lab_wire.sym} 300 -150 0 0 {name=p4 lab=SWR[3:0]}
C {lab_wire.sym} 600 -130 0 1 {name=p5 lab=IN[3:0]}
C {lab_wire.sym} 600 -110 0 1 {name=p6 lab=OUT[3:0]}
C {iopin.sym} 120 -180 0 0 {name=p3 lab=VDD}
C {iopin.sym} 120 -160 0 0 {name=p7 lab=VSS}
C {iopin.sym} 120 -140 0 0 {name=p8 lab=IN[3:0]}
C {iopin.sym} 120 -120 0 0 {name=p9 lab=OUT[3:0]}
C {ipin.sym} 120 -100 0 0 {name=p10 lab=SWR[3:0]}
C {switch_cell.sym} 450 -140 0 0 {name=x2[3:0]}
C {lab_wire.sym} 300 -130 0 0 {name=p11 lab=SWC}
C {lab_wire.sym} 300 -170 0 0 {name=p12 lab=CLK}
C {ipin.sym} 120 -80 0 0 {name=p13 lab=SWC}
C {ipin.sym} 120 -60 0 0 {name=p14 lab=CLK}
