v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {transmission_gate.sym} 400 -250 0 0 {name=x1[3:0]}
C {lab_wire.sym} 290 -330 0 0 {name=p1 lab=VDD}
C {lab_wire.sym} 290 -310 0 0 {name=p2 lab=VSS}
C {lab_wire.sym} 400 -200 0 0 {name=p3 lab=SWN}
C {lab_wire.sym} 400 -300 0 0 {name=p4 lab=SWP}
C {lab_wire.sym} 290 -250 0 0 {name=p5 lab=IN[3:0]}
C {lab_wire.sym} 510 -250 0 1 {name=p6 lab=OUT[3:0]}
