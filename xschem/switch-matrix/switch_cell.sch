v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {transmission_gate.sym} 430 -420 0 0 {name=x1}
C {lab_wire.sym} 580 -450 0 1 {name=p1 lab=VDD}
C {lab_wire.sym} 580 -430 0 1 {name=p2 lab=VSS}
C {lab_wire.sym} 280 -450 0 0 {name=p3 lab=Q}
C {lab_wire.sym} 580 -410 0 1 {name=p4 lab=IN}
C {lab_wire.sym} 580 -390 0 1 {name=p5 lab=OUT}
C {dff_tspc.sym} 430 -300 0 0 {name=x2}
C {lab_wire.sym} 580 -330 0 1 {name=p6 lab=VDD}
C {lab_wire.sym} 580 -310 0 1 {name=p7 lab=VSS}
C {lab_wire.sym} 280 -330 0 0 {name=p8 lab=SW}
C {lab_wire.sym} 280 -310 0 0 {name=p9 lab=CLK}
C {lab_wire.sym} 580 -290 0 1 {name=p10 lab=Q}
C {and2_1.sym} 430 -190 0 0 {name=x3}
C {lab_wire.sym} 580 -210 0 1 {name=p12 lab=VDD}
C {lab_wire.sym} 580 -190 0 1 {name=p13 lab=VSS}
C {lab_wire.sym} 280 -210 0 0 {name=p14 lab=SWR}
C {lab_wire.sym} 280 -190 0 0 {name=p15 lab=SWC}
C {lab_wire.sym} 580 -170 0 1 {name=p16 lab=SW}
C {noconn.sym} 580 -270 0 1 {name=l1}
C {iopin.sym} 120 -440 0 0 {name=p11 lab=VDD}
C {iopin.sym} 120 -420 0 0 {name=p17 lab=VSS}
C {ipin.sym} 120 -400 0 0 {name=p18 lab=CLK}
C {ipin.sym} 120 -380 0 0 {name=p19 lab=SWR}
C {ipin.sym} 120 -360 0 0 {name=p20 lab=SWC}
C {iopin.sym} 120 -340 0 0 {name=p21 lab=IN}
C {iopin.sym} 120 -320 0 0 {name=p22 lab=OUT}
